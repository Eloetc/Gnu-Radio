options:
  parameters:
    author: Kevin
    description: Einfaches UKW/FM-Radio (WBFM) mit RTL-SDR
    generate_options: qt_gui
    id: fm_radio
    output_language: python
    title: UKW / FM Radio
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Sender-Frequenz (Hz)
    orient: Qt.Horizontal
    start: 87.5e6
    step: 100e3
    stop: 108e6
    value: 98.5e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Lautstärke
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain (dB)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '49'
    value: '40'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '50'
    comment: 2400000 / 50 = 48000 Hz Audio
    quad_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"Spektrum"'
    type: complex
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', analog_wfm_rcv_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
